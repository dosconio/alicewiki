# Keil uVision project lcd1602keil.uvproj, settings and files
target LCD1602Keil (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: lcd1602keil +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: _DEV_KEIL _MCU_Intel8051 _SYS_FREQ=11059200
  c include: M:\her\SVGN\unisym\inc\c;M:\her\SVGN\unisym\inc\c\driver;M:\her\SVGN\unisym\inc\c\datype;M:\her\SVGN\unisym\inc\c\system;M:\her\SVGN\unisym\inc\c\MCU\Intel
  group Source Group
    ./: main.c
    ../../: STARTUP.A51
  group Unisym Group
    M:/her/SVGN/_bin/mcu/: u8051x89C5.LIB
    M:/her/SVGN/unisym/lib/c/driver/: HD44780.c
    M:/her/SVGN/unisym/lib/c/driver/device/: LCD1602.c
    M:/her/SVGN/unisym/lib/c/: delay.c
